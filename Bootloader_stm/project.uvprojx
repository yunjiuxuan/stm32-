# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: D:\develop\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\project.bin .\Objects\project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\Application;.\Public;.\Bsp;.\RTE;.\RTE\Device;.\RTE\Device\STM32F407ZE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3ffff
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Public
    ./Public/: delay.c
  group Bsp
    ./Bsp/: reg_led.c func_led.c dsp_usart.c w25q128.c spi.c 24c02.c iic.c led.c oled.c oled_display.c pwm.c
  group User
    ./: main.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
