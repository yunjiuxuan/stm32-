# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x080A0000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: D:\develop\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o .\Objects\project.bin .\Objects\project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\Application;.\Public;.\Dsp;.\RTE;.\RTE\Device;.\RTE\Device\STM32F407ZE;.\portable\RVDS\ARM_CM4F;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x5ffff
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Public
    ./Public/: delay.c
  group Dsp
    ./Dsp/: dsp_usart.c func_led.c iic.c oled.c reg_led.c 24c02.c oled_display.c key.c led.c key_task.c sr04_task.c dht11.c pwm.c func_beep.c
    ./: bt_task.c bemfa_task.c
  group User
    ./: main.c
  group FreeRTOS_CODE
    ./: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./portable/MemMang/: heap_4.c
    ./portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
